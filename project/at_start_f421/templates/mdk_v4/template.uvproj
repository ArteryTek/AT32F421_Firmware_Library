# Keil uVision project template.uvproj, settings and files
target tempate (ARM-ADS)
  device: -AT32F421C8T7 ArteryTek
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\..\..\libraries\drivers\inc;..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\libraries\cmsis\cm4\device_support;..\inc;..\..\..\at32f421_board
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_int.c at32f421_clock.c main.c
  group bsp
    ../../../at32f421_board/: at32f421_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f421.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f421.c
  group firmware
    ../../../../libraries/drivers/src/: at32f421_adc.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c at32f421_cmp.c
  group readme
    ../: readme.txt
