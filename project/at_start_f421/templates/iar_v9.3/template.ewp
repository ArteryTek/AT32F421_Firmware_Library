# IAR project template.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: AT32F421C8T7_v2 ArteryTek -AT32F421C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 0
  ICCARM.CCDefines: AT32F421C8T7; USE_STDPERIPH_DRIVER; AT_START_F421_V1
  ICCARM.CCIncludePath2: ..\..\..\..\libraries\drivers\inc; ..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\at32f421_board
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: template.srec
  ILINK.IlinkOutputFile: template.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group bsp
    ../../../at32f421_board/: at32f421_board.c
  group cmsis
    ../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f421.s
    ../../../../libraries/cmsis/cm4/device_support/: system_at32f421.c
  group firmware
    ../../../../libraries/drivers/src/: at32f421_adc.c at32f421_cmp.c at32f421_crc.c at32f421_crm.c at32f421_debug.c at32f421_dma.c at32f421_ertc.c at32f421_exint.c at32f421_flash.c at32f421_gpio.c at32f421_i2c.c at32f421_misc.c at32f421_pwc.c at32f421_scfg.c at32f421_spi.c at32f421_tmr.c at32f421_usart.c at32f421_wdt.c at32f421_wwdt.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f421_clock.c at32f421_int.c main.c
