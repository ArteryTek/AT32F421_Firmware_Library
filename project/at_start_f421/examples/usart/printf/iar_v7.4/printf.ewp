# IAR project printf.ewp, settings and files
configuration printf (ARM)
  General.OGChipSelectEditMenu: AT32F421C8T7_v2 ArteryTek -AT32F421C8T7
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: AT32F421C8T7; USE_STDPERIPH_DRIVER; AT_START_F421_V1
  ICCARM.CCIncludePath2: ..\..\..\..\..\..\libraries\drivers\inc; ..\..\..\..\..\..\libraries\cmsis\cm4\core_support; ..\..\..\..\..\..\libraries\cmsis\cm4\device_support; ..\inc; ..\..\..\..\..\at32f421_board
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: printf.srec
  ILINK.IlinkOutputFile: printf.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
  group bsp
    ../../../../../at32f421_board/: at32f421_board.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/startup/iar/: startup_at32f421.s
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f421.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f421_crm.c at32f421_gpio.c at32f421_misc.c at32f421_usart.c
  group readme
    ../: readme.txt
  group user
    ../src/: at32f421_int.c at32f421_clock.c main.c
