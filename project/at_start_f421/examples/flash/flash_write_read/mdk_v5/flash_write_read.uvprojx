# Keil uVision project flash_write_read.uvprojx, settings and files
target flash_write_read (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: -AT32F421C8T7 ArteryTek
  pack: ArteryTek.AT32F421_DFP.2.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M4") CLOCK(12000000) ELITTLE
  output: flash_write_read +hex
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: AT32F421C8T7,USE_STDPERIPH_DRIVER,AT_START_F421_V1
  c include: ..\..\..\..\..\..\libraries\drivers\inc;..\..\..\..\..\..\libraries\cmsis\cm4\core_support;..\..\..\..\..\..\libraries\cmsis\cm4\device_support;..\..\..\..\..\at32f421_board;..\flash;..\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group user
    ../src/: at32f421_clock.c at32f421_int.c flash.c main.c
  group bsp
    ../../../../../at32f421_board/: at32f421_board.c
  group firmware
    ../../../../../../libraries/drivers/src/: at32f421_gpio.c at32f421_crm.c at32f421_usart.c at32f421_flash.c at32f421_misc.c
  group cmsis
    ../../../../../../libraries/cmsis/cm4/device_support/: system_at32f421.c
    ../../../../../../libraries/cmsis/cm4/device_support/startup/mdk/: startup_at32f421.s
  group readme
    ../: readme.txt
