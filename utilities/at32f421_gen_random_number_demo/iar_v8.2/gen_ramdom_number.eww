<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\gen_ramdom_number.ewp</path>
    </project>
</workspace>
